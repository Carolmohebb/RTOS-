# Keil uVision project SmartGate.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartGate
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: .\FreeRtos\include;.\FreeRtos;.\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group FreeRTOS_Core
    ./FreeRtos/: tasks.c queue.c list.c event_groups.c stream_buffer.c
  group FreeRTOS_Port
    ./FreeRtos/: port.c heap_4.c startup_TM4C123.s
  group App
    ./src/: FreeRTOSConfig.h main.c system_TM4C123.c gpio_driver.c shared_types.h
